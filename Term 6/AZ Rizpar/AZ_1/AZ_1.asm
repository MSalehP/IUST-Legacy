.include "m32def.inc"
		; 400521171 MOHAMMAD SALEH PAZHAND

		LDI		R16,HIGH(RAMEND)
		OUT		SPH,R16
		LDI		R16,LOW(RAMEND)
		OUT		SPL,R16

		LDI		R16,0xFF
		OUT		DDRB,R16
		LDI		R20,0b00000001
		
START:	
		LDI		R20,0b00000001
ROLLDOWN:
		OUT		PORTB,R20
		CALL	DELAY
		LSL		R20
		BRNE	ROLLDOWN
		LDI		R20,0b10000000
ROLLUP:	
		OUT		PORTB,R20
		CALL	DELAY
		LSR		R20
		BRNE	ROLLUP
		RJMP	START


DELAY:	IN		R17,PINA
D1:		LDI		R18,0X0F
D2:		LDI		R19,100
D3:		DEC		R19
		BRNE	D3
		DEC		R18
		BRNE	D2
		DEC		R17
		BRNE	D1
		RET

